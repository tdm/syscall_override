## Kconfig
```kconfig
config SYSCALL_OVERRIDE
	tristate "Syscall Override"
	--help--
	  Help messagage for SYSCALL_OVERRIDE
```
